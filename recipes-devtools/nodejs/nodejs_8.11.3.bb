require nodejs_8.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=fde91d5c5bbd1e0389623e1ac018d9e8"

SRC_URI[src.md5sum] = "7dc43199182a9451c8207076d9260b24"
SRC_URI[src.sha256sum] = "0d7e795c0579226c8b197353bbb9392cae802f4fefa4787a2c0e678beaf85cce"
